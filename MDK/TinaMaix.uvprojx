# Keil uVision project TinaMaix.uvprojx, settings and files
target APM32F072 (6130001::V6.13.1::.\ARMCLANG)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TinaMaix
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BOARD_APM32F072_MINI,APM32F072xB
  c include: ..\Library\APM32F0xx_StdPeriphDriver\inc;..\Library\CMSIS\Include;..\Library\Device\Geehy\APM32F0xx\Include;..\Board;..\Include;..\TinyMaix\include;..\TinyMaix\src;..\TinyMaix\tools\tmdl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Library/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f072.s
    ../Library/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
  group StdPeriphDriver
    ../Library/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group Application
    ../Source/: apm32f0xx_int.c main.c
  group TinaMaix
    ../TinyMaix/src/: tm_layers.c tm_layers_O1.c tm_model.c tm_stat.c
